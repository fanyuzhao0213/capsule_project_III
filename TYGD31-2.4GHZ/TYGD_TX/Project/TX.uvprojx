# Keil uVision project TX.uvprojx, settings and files
target debug (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TX +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_GPIO_AS_PINRESET, NRF52, DEBUG,
  c misc: --c99
  c include: ..\application;..\common;..\nRF\core;..\nRF\system;..\nRF\driver;..\device;..\device\dev_cx93510
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group nRF_core
    ../nRF/core/: arm_startup_nrf52.s
  group nRF_system
    ../nRF/system/: system_clock.c system_nrf52.c system_tick.c system_it_vector.c
  group nRF_driver
    ../nRF/driver/: drv_gpio.c drv_radio.c drv_spi.c drv_timer.c drv_wdt.c drv_flash.c
  group application
    ../application/: domain.c main.c
    ../Application/: capsule_sn_broadcast.c image.c
  group common
    ../common/: delay.c common.h config.h define.h delay.h protocol.h typedef.h version.h
  group device
    ../device/dev_cx93510/: dev_cx93510.c dev_sensor.c
    ../device/: dev_led.c
