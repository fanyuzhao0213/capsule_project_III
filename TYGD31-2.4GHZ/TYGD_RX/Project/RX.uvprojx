# Keil uVision project RX.uvprojx, settings and files
target debug (ARM-ADS)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.17.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: RF +hex
  AfterMake: fromelf.exe --bin -o  ./debug/RF.bin ./debug/RF.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: CONFIG_GPIO_AS_PINRESET, CONFIG_NFCT_PINS_AS_GPIOS, NRF52,DEBUG
  c misc: --c99
  c include: ..\Application;..\common;..\nRF\core;..\nRF\system;..\nRF\driver;..\device;..\dtm
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x64000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group nRF_core
    ../nRF/core/: arm_startup_nrf52.s
  group nRF_system
    ../nRF/system/: system_clock.c system_nrf52.c system_it_vector.c
  group nRF_driver
    ../nRF/driver/: drv_gpio.c drv_radio.c drv_timer.c drv_uart.c drv_wdt.c drv_flash.c drv_systick.c driver.c
  group application
    ../application/: domain.c main.c
    ../Application/: capsule_sn_binding.c antenna.c image.c
  group common
    ../common/: delay.c
  group device
    ../device/: dev_rf1662.c
