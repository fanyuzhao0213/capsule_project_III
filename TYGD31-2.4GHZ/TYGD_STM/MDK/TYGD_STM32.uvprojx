# Keil uVision project TYGD_STM32.uvprojx, settings and files
target debug (ARM-ADS)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: tygd_stm32 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD, DEBUG
  c include: ..\APP;..\COMMON;..\FATFS;..\FWLIB\src;..\FWLIB\inc;..\STM32F103\core;..\STM32F103\driver;..\STM32F103\system;..\USER
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STM32_core
    ../STM32F103/core/: startup_stm32f10x_hd.s
  group STM32_system
    ../STM32F103/system/: system_stm32f10x.c system_stm32_rcc.c system_stm32_tick.c system_stm32_vector.c
  group STM32_driver
    ../STM32F103/driver/: drv_power_mode.c drv_usart.c drv_wdt.c drv_sd2058.c
  group user
    ../USER/: stm32f10x_it.c stm3210e_eval.c stm3210e_eval_sdio_sd.c
  group app
    ../APP/: main.c do_main.c storage_card.c receive_send_image.c jpeg_head.c device_info.c time_handle.c usart_transfer_station.c calendar.c exti.c bsp_TiMbase.c
  group common
    ../COMMON/: delay.c delay.h common.h define.h sys.h integer.h protocol.h version.h
  group fatfs
    ../FATFS/: diskio.c ff.c cc936.c
  group lib
    ../FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_rtc.c stm32f10x_wwdg.c stm32f10x_adc.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_tim.c
