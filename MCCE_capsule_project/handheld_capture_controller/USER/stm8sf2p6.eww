<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\stm8sf2p6.ewp</path>
    </project>
    <batchBuild />
</workspace>
