# IAR project stm8sf2p6.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S103F2P STM8S103F2P
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S103
  ICCSTM8.CCIncludePath2: $PROJ_DIR$; $TOOLKIT_DIR$\inc\c; ..\STM8_FWLIB\inc; ..\BSP; ..\MyCode
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: stm8sf2p6.hex
  ILINK.IlinkOutputFile: stm8sf2p6.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group BSP
    ../BSP/: bsp_delay.c bsp_delay.h bsp_uart.c bsp_uart.h
  group STM8_FWLIB
    ../STM8_FWLIB/src/: stm8s_adc1.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim4.c stm8s_uart1.c stm8s_wwdg.c
  group USER
    ./: main.c stm8s_it.c
